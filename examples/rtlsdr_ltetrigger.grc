<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>Douglas Anderson</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>qt_qss_theme</key><value>/usr/local/share/gnuradio/themes/alt.qss</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>gr-ltetrigger RTL-SDR Demo</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>cell_cp_mode</value></param>
<param><key>value</key><value>cell_details_probe</value></param>
<param><key>formatter</key><value>lambda *x: str(pmt.to_python(*x)['cp_len']) if x and not pmt.is_null(*x) else None</value></param>
<param><key>gui_hint</key><value>8,1,1,1</value></param>
<param><key>label</key><value>CP Mode</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>cell_details_probe</value></param>
<param><key>block_id</key><value>ltetrigger_cellstore</value></param>
<param><key>function_name</key><value>latest_cell</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>value</key><value>pmt.PMT_NIL</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>cell_id_label</value></param>
<param><key>value</key><value>cell_details_probe</value></param>
<param><key>formatter</key><value>lambda *x: int(pmt.to_python(*x)['cell_id']) if x and not pmt.is_null(*x) else None</value></param>
<param><key>gui_hint</key><value>4,1,1,1</value></param>
<param><key>label</key><value>Cell ID</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>cell_nof_phich_resources</value></param>
<param><key>value</key><value>cell_details_probe</value></param>
<param><key>formatter</key><value>lambda *x: str(pmt.to_python(*x)['nof_phich_resources']) if x and not pmt.is_null(*x) else None</value></param>
<param><key>gui_hint</key><value>7,1,1,1</value></param>
<param><key>label</key><value>PHICH Resources</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>cell_nof_prb</value></param>
<param><key>value</key><value>cell_details_probe</value></param>
<param><key>formatter</key><value>lambda *x: int(pmt.to_python(*x)['nof_prb']) if x and not pmt.is_null(*x) else None</value></param>
<param><key>gui_hint</key><value>6,1,1,1</value></param>
<param><key>label</key><value>PRBs</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>cell_tracking_start_time_label</value></param>
<param><key>value</key><value>cell_details_probe</value></param>
<param><key>formatter</key><value>lambda *x: time.strftime("%b %d %Y %H:%M%S GMT", time.gmtime(pmt.to_python(*x)['tracking_start_time'])) if x and not pmt.is_null(*x) else None</value></param>
<param><key>gui_hint</key><value>5,1,1,1</value></param>
<param><key>label</key><value>Tracking Start Time</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>751e6</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>psr_threshold</value></param>
<param><key>comment</key><value>Attempt signal demodulation
when the PSS blocks reports
a PSR (peak to side-lobe ratio)
above this threshold.</value></param>
<param><key>value</key><value>3</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>label</key><value>Demod Threshold (PSR)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1.5</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1.92e6</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>samp_rate_label</value></param>
<param><key>value</key><value>samp_rate</value></param>
<param><key>formatter</key><value>lambda *x: "{:.2f} MHz".format(x[0] / float(1e6)) if x else ""</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>tracking_0</value></param>
<param><key>value</key><value>tracking_probe</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label</key><value>Tracking</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>tracking_probe</value></param>
<param><key>block_id</key><value>ltetrigger_cellstore</value></param>
<param><key>function_name</key><value>tracking</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>tracking_score_0</value></param>
<param><key>value</key><value>tracking_score_probe_0</value></param>
<param><key>gui_hint</key><value>3,2,1,1</value></param>
<param><key>label</key><value>N_id_2 0 Tracking Score</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>tracking_score_1</value></param>
<param><key>value</key><value>tracking_score_probe_1</value></param>
<param><key>gui_hint</key><value>4,2,1,1</value></param>
<param><key>label</key><value>N_id_2 1 Tracking Score</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>tracking_score_2</value></param>
<param><key>value</key><value>tracking_score_probe_2</value></param>
<param><key>gui_hint</key><value>5,2,1,1</value></param>
<param><key>label</key><value>N_id_2 2 Tracking Score</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>tracking_score_probe_0</value></param>
<param><key>block_id</key><value>ltetrigger_downlink_trigger_c.pss0</value></param>
<param><key>function_name</key><value>tracking_score</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>tracking_score_probe_1</value></param>
<param><key>block_id</key><value>ltetrigger_downlink_trigger_c.pss1</value></param>
<param><key>function_name</key><value>tracking_score</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>tracking_score_probe_2</value></param>
<param><key>block_id</key><value>ltetrigger_downlink_trigger_c.pss2</value></param>
<param><key>function_name</key><value>tracking_score</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_pmt</value></param>
<param><key>import</key><value>import pmt</value></param>
</block>
<block>
<key>ltetrigger_cellstore</key>
<param><key>id</key><value>ltetrigger_cellstore</value></param>
</block>
<block>
<key>ltetrigger_downlink_trigger_c</key>
<param><key>id</key><value>ltetrigger_downlink_trigger_c</value></param>
<param><key>exit_on_success</key><value>False</value></param>
<param><key>psr_threshold</key><value>psr_threshold</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>frequency</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>frequency</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>2,1,1,3</value></param>
<param><key>int_max</key><value>-40</value></param>
<param><key>int_min</key><value>-100</value></param>
<param><key>color1</key><value>6</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.05</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>ltetrigger_downlink_trigger_c</source_block_id><sink_block_id>ltetrigger_cellstore</sink_block_id><source_key>drop</source_key><sink_key>drop</sink_key></connection>
<connection><source_block_id>ltetrigger_downlink_trigger_c</source_block_id><sink_block_id>ltetrigger_cellstore</sink_block_id><source_key>track</source_key><sink_key>track</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>ltetrigger_downlink_trigger_c</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
