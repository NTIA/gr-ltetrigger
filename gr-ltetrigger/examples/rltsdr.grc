<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>751e6</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>psr_threshold</value></param>
<param><key>value</key><value>1.5</value></param>
<param><key>label</key><value>PSR Threshold</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>psr_threshold_label</value></param>
<param><key>value</key><value>psr_threshold_probe</value></param>
<param><key>label</key><value>PSR Treshold</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>psr_threshold_probe</value></param>
<param><key>block_id</key><value>ltetrigger_downlink_trigger_c.pss0</value></param>
<param><key>function_name</key><value>psr_threshold</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>pss0_max_psr</value></param>
<param><key>value</key><value>pss0_max_psr_probe</value></param>
<param><key>label</key><value>PSS0 Max PSR</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>pss0_max_psr_probe</value></param>
<param><key>block_id</key><value>ltetrigger_downlink_trigger_c.pss0</value></param>
<param><key>function_name</key><value>max_psr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>pss0_mean_cfo</value></param>
<param><key>value</key><value>pss0_mean_cfo_probe</value></param>
<param><key>label</key><value>PSS0 Mean CFO</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>pss0_mean_cfo_probe</value></param>
<param><key>block_id</key><value>ltetrigger_downlink_trigger_c.pss0</value></param>
<param><key>function_name</key><value>mean_cfo</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>pss0_mean_psr</value></param>
<param><key>value</key><value>pss0_mean_psr_probe</value></param>
<param><key>label</key><value>PSS0 Mean PSR</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>pss0_mean_psr_probe</value></param>
<param><key>block_id</key><value>ltetrigger_downlink_trigger_c.pss0</value></param>
<param><key>function_name</key><value>mean_psr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>pss1_max_psr</value></param>
<param><key>value</key><value>pss1_max_psr_probe</value></param>
<param><key>label</key><value>PSS1 Max PSR</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>pss1_max_psr_probe</value></param>
<param><key>block_id</key><value>ltetrigger_downlink_trigger_c.pss1</value></param>
<param><key>function_name</key><value>max_psr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>pss1_mean_cfo</value></param>
<param><key>value</key><value>pss1_mean_cfo_probe</value></param>
<param><key>label</key><value>PSS1 Mean CFO</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>pss1_mean_cfo_probe</value></param>
<param><key>block_id</key><value>ltetrigger_downlink_trigger_c.pss1</value></param>
<param><key>function_name</key><value>mean_cfo</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>pss1_mean_psr</value></param>
<param><key>value</key><value>pss1_mean_psr_probe</value></param>
<param><key>label</key><value>PSS1 Mean PSR</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>pss1_mean_psr_probe</value></param>
<param><key>block_id</key><value>ltetrigger_downlink_trigger_c.pss1</value></param>
<param><key>function_name</key><value>mean_psr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>pss2_max_psr</value></param>
<param><key>value</key><value>pss2_max_psr_probe</value></param>
<param><key>label</key><value>PSS2 Max PSR</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>pss2_max_psr_probe</value></param>
<param><key>block_id</key><value>ltetrigger_downlink_trigger_c.pss2</value></param>
<param><key>function_name</key><value>max_psr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>pss2_mean_cfo</value></param>
<param><key>value</key><value>pss2_mean_cfo_probe</value></param>
<param><key>label</key><value>PSS2 Mean CFO</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>pss2_mean_cfo_probe</value></param>
<param><key>block_id</key><value>ltetrigger_downlink_trigger_c.pss2</value></param>
<param><key>function_name</key><value>mean_cfo</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>pss2_mean_psr</value></param>
<param><key>value</key><value>pss2_mean_psr_probe</value></param>
<param><key>label</key><value>PSS2 Mean PSR</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>pss2_mean_psr_probe</value></param>
<param><key>block_id</key><value>ltetrigger_downlink_trigger_c.pss2</value></param>
<param><key>function_name</key><value>mean_psr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1.92e6</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>tracking_score_0</value></param>
<param><key>value</key><value>tracking_score_probe_0</value></param>
<param><key>label</key><value>N_id_0 Tracking Score: </value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>tracking_score_1</value></param>
<param><key>value</key><value>tracking_score_probe_1</value></param>
<param><key>label</key><value>N_id_1 Tracking Score: </value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>tracking_score_2</value></param>
<param><key>value</key><value>tracking_score_probe_2</value></param>
<param><key>label</key><value>N_id_2 Tracking Score: </value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>tracking_score_probe_0</value></param>
<param><key>block_id</key><value>ltetrigger_downlink_trigger_c.pss0</value></param>
<param><key>function_name</key><value>tracking_score</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>4</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>tracking_score_probe_1</value></param>
<param><key>block_id</key><value>ltetrigger_downlink_trigger_c.pss1</value></param>
<param><key>function_name</key><value>tracking_score</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>tracking_score_probe_2</value></param>
<param><key>block_id</key><value>ltetrigger_downlink_trigger_c.pss2</value></param>
<param><key>function_name</key><value>tracking_score</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>ltetrigger_downlink_trigger_c</key>
<param><key>id</key><value>ltetrigger_downlink_trigger_c</value></param>
<param><key>exit_on_success</key><value>False</value></param>
<param><key>psr_threshold</key><value>psr_threshold</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>frequency</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>ltetrigger_downlink_trigger_c</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>tracking_cell</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>ltetrigger_downlink_trigger_c</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
