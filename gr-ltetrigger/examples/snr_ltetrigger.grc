<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>Douglas Anderson</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Test LTE downlink detection at different SNR</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>SNR LTETrigger Demo</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>cell_cp_mode</value></param>
<param><key>value</key><value>cell_details_probe</value></param>
<param><key>formatter</key><value>lambda *x: str(pmt.to_python(*x)['cp_len']) if x and not pmt.is_null(*x) else None</value></param>
<param><key>gui_hint</key><value>6,1,1,1</value></param>
<param><key>label</key><value>CP Mode</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>cell_details_probe</value></param>
<param><key>block_id</key><value>ltetrigger_cellstore</value></param>
<param><key>function_name</key><value>latest_cell</value></param>
<param><key>poll_rate</key><value>2</value></param>
<param><key>value</key><value>pmt.PMT_NIL</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>cell_id_label</value></param>
<param><key>value</key><value>cell_details_probe</value></param>
<param><key>formatter</key><value>lambda *x: int(pmt.to_python(*x)['cell_id']) if x and not pmt.is_null(*x) else None</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>label</key><value>Cell ID</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>cell_nof_phich_resources</value></param>
<param><key>value</key><value>cell_details_probe</value></param>
<param><key>formatter</key><value>lambda *x: str(pmt.to_python(*x)['nof_phich_resources']) if x and not pmt.is_null(*x) else None</value></param>
<param><key>gui_hint</key><value>5,1,1,1</value></param>
<param><key>label</key><value>PHICH Resources</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>cell_nof_prb</value></param>
<param><key>value</key><value>cell_details_probe</value></param>
<param><key>formatter</key><value>lambda *x: int(pmt.to_python(*x)['nof_prb']) if x and not pmt.is_null(*x) else None</value></param>
<param><key>gui_hint</key><value>4,1,1,1</value></param>
<param><key>label</key><value>PRBs</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>cell_tracking_start_time_label</value></param>
<param><key>value</key><value>cell_details_probe</value></param>
<param><key>formatter</key><value>lambda *x: time.strftime("%b %d %Y %H:%M%S GMT", time.gmtime(pmt.to_python(*x)['tracking_start_time'])) if x and not pmt.is_null(*x) else None</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label</key><value>Tracking Start Time</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise_ampl</value></param>
<param><key>value</key><value>0.001</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>psr_threshold</value></param>
<param><key>comment</key><value>Attempt signal demodulation
when the PSS blocks reports
a PSR (peak to side-lobe ratio)
above this threshold.</value></param>
<param><key>value</key><value>3</value></param>
<param><key>gui_hint</key><value>4,0,3,1</value></param>
<param><key>label</key><value>Demod Threshold (PSR)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1.5</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1.92e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>signal_gain</value></param>
<param><key>value</key><value>0.005</value></param>
<param><key>gui_hint</key><value>1,0,3,1</value></param>
<param><key>label</key><value>Signal Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.00001</value></param>
<param><key>step</key><value>0.00005</value></param>
<param><key>stop</key><value>0.005</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>tracking</value></param>
<param><key>value</key><value>tracking_probe</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Tracking</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>tracking_probe</value></param>
<param><key>block_id</key><value>ltetrigger_cellstore</value></param>
<param><key>function_name</key><value>tracking</value></param>
<param><key>poll_rate</key><value>4</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>noise_ampl</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>1000</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1/1000.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0_0</value></param>
<param><key>length</key><value>1000</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1/1000.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>signal_gain</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_0</value></param>
<param><key>k</key><value>13.010299956639813</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_0_0</value></param>
<param><key>k</key><value>13.010299956639813</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>file_source</value></param>
<param><key>file</key><value>/home/dja/dev/ltetrigger/gr-ltetrigger/python/test_data/lte_frame_6prb_cellid_123</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_pmt</value></param>
<param><key>import</key><value>import pmt</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_pmt_0</value></param>
<param><key>import</key><value>import time</value></param>
</block>
<block>
<key>ltetrigger_cellstore</key>
<param><key>id</key><value>ltetrigger_cellstore</value></param>
</block>
<block>
<key>ltetrigger_downlink_trigger_c</key>
<param><key>id</key><value>ltetrigger_downlink_trigger</value></param>
<param><key>exit_on_success</key><value>False</value></param>
<param><key>psr_threshold</key><value>psr_threshold</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label1</key><value>Signal</value></param>
<param><key>label2</key><value>Noise</value></param>
<param><key>label3</key><value>Signal+Noise</value></param>
<param><key>name</key><value>Power Spectral Density</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-40</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Signal Power</value></param>
<param><key>unit1</key><value>dBm</value></param>
<param><key>label2</key><value>Noise Power</value></param>
<param><key>unit2</key><value>dBm</value></param>
<param><key>label3</key><value>SNR</value></param>
<param><key>unit3</key><value>dB</value></param>
<param><key>max</key><value>50</value></param>
<param><key>min</key><value>-120</value></param>
<param><key>name</key><value>SNR</value></param>
<param><key>nconnections</key><value>3</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>ltetrigger_downlink_trigger</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>blocks_moving_average_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>file_source</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ltetrigger_downlink_trigger</source_block_id><sink_block_id>ltetrigger_cellstore</sink_block_id><source_key>drop</source_key><sink_key>drop</sink_key></connection>
<connection><source_block_id>ltetrigger_downlink_trigger</source_block_id><sink_block_id>ltetrigger_cellstore</sink_block_id><source_key>track</source_key><sink_key>track</sink_key></connection>
</flow_graph>
